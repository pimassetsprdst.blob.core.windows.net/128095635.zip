Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-04-12T15:40:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 12 15:40:08 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{1D40018B-86FB-47A9-ACAC-2114D561911C}\ifc * Database version: 5507 * Database creation date: Thu Apr 12 15:40:06 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Apr 12 15:40:06 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 12 15:40:06 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: DLR-A4.8.1.1, E_Gateway_MEPcontent_ABB_DALI Light Controller_DLR_A4 8 1 1_INT-EN:DLR-A4.8.1.1:1398111
In: V00
Type - Material: Color RGB 084-090-090, Color RGB 255-000-000, Color RGB 197-199-196
Type - Dimensions - Depth: 202 mm; Height: 147 mm; Rotation U-Axis Correction: 90 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 0 deg; Width: 50 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical - Loads - Power: 0 W
Type - Identity Data - Article Description: DLR/A4.8.1.1 DALI Light Cont, 4f, SM; Article Type: DLR/A4.8.1.1; Category: EL_BUSSYSTEM_SENSOR; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: DLR/A4.8.1.1 DALI Light Cont, 4f, SM; EMCS Version: 3.0; ETIM Article Class: EC001099; Family Version: 11.14; GTIN: 4016779882378; Manufacturer: ABB; Manufacturer Art. No.: 2CDG110172R0011; Manufacturer URL: https://new.abb.com/products/2CDG110172R0011; MEPcontent Class: GATEWAY; Model: DLR/A4.8.1.1; OmniClass Number: 23.80.10.17.24; OmniClass Title: Direct Current (DC) Drive Controllers; Product Line: KNX - Lighting Control - DALI Gateways and Light Controllers; Revit Version: 2016; Type Name: DLR-A4.8.1.1; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Communication Devices; Family Name: E_Gateway_MEPcontent_ABB_DALI Light Controller_DLR_A4 8 1 1_INT-EN
Pset_BuildingElementProxyCommon - Reference: DLR-A4.8.1.1; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.074467 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.00122458 m3
Identity Data - Function Code: E6222BS; Mark: 2
Other - Family: E_Gateway_MEPcontent_ABB_DALI Light Controller_DLR_A4 8 1 1_INT-EN: DLR-A4.8.1.1; Family and Type: E_Gateway_MEPcontent_ABB_DALI Light Controller_DLR_A4 8 1 1_INT-EN: DLR-A4.8.1.1; Type: E_Gateway_MEPcontent_ABB_DALI Light Controller_DLR_A4 8 1 1_INT-EN: DLR-A4.8.1.1; Type Id: E_Gateway_MEPcontent_ABB_DALI Light Controller_DLR_A4 8 1 1_INT-EN: DLR-A4.8.1.1
Phasing - Phase Created: 3. Nieuwbouw
